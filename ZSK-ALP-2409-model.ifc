Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:19:26+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-ALP-2409
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Комплекс скалолазный, ZSK-ALP-2409 Скалодром «Орбита»
In: Площадка
Description: Комплекс скалолазный. Скалодром «Орбита»; Classification: 59.1.15.01-0911 Стенка для лазания (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-ALP-2409; ModelReference: Скалодром «Орбита»; ProductionYear: 2026; ArticleNumber: ZSK-ALP-2409
ORION_Изделие - Артикул: ZSK-ALP-2409; Артикул прежний: SD-ALP-2409; Наименование: Скалодром «Орбита»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: Ø 6 500 × 6 500 × 2 800 мм; Возраст: от 8 лет; Цена: 1 600 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/climbing/30916; Код КСИ: CPr>EDB250; Класс КСИ: Стенка для лазания; Коды КСР: 59.1.15.01-0911 … 59.1.15.01-0911
ADSK - ADSK_Наименование: Скалодром «Орбита»; ADSK_Марка: ZSK-ALP-2409; ADSK_Код изделия: 59.1.15.01-0911; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/climbing/30916
ZSK_Благоустройство - ZSK_Возрастная_группа: от 8 лет; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB250; ZSK_Артикул_прежний: SD-ALP-2409
Qto_ORION - Длина: 6 mm; Ширина: 6 mm; Высота: 500 mm
